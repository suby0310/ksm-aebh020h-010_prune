# Keil uVision project KSM-AEBH020H-010_SDK.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MODP2
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./src/: startup.a51 common_types.c DAB_DLS_Handler.c DAB_Service_List_Handler.c delay.c Firmware_API_Manager.c Firmware_Load_Helpers.c FMHD_Alert_Handler.c FMHD_PSD_Handler.c FMHD_Service_List_Handler.c FMHD_SIS_Handler.c HAL.c Hardware_Calibration_Helpers.c in_chip_eeprom.c key.c LCD.c main.c mode_common.c mode_dab.c mode_fm_am.c mode_fmhd_amhd.c mode_other.c mode_slave.c RDS_Handler.c SDK_Callbacks.c si46xx_firmware_api.c si468x_bus.c sys.c uart.c utility.c bootcode.c
